Commit message: Add files via upload

File: ruka_config_novy/config/gazebo_cr5_robot.urdf (robot description, URDF)
Before this commit: robot cr5_robot, 10 links, 9 joints
Joints:
- joint tcp_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=-0.105 0 0.065 rpy=0 3.1416 1.5708
